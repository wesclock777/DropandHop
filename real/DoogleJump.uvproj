# Keil uVision project DoogleJump.uvproj, settings and files
target DoogleJump (ARM-ADS)
  device: TM4C1231C3PM Texas Instruments
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x7FFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: DoogleJump
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group Source
    ./: startup_TM4C123.s DoogleJump.c
    ../DropandHop/Keil Project/: ST7735.c ST7735.h
