# Keil uVision project Dropandhop.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C1231C3PM Texas Instruments
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x7FFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Dropandhop
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group New Group
    ./: Lab10Main.c SysTick.c ST7735.c startup.s tm4c123gh6pm.h
